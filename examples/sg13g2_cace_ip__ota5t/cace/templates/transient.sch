** sch_path: examples/sg13g2_cace_ip__ota5t/cace/templates/transient.sch
**.subckt transient
I0 VDD Ib CACE{ib}
C1 Vout GND CACE{cl} m=1
V0 VSS GND 0
V2 VDD GND CACE{vdd}
x2 Vp Vn Vout VDD VSS Ib sg13g2_cace_ip__ota5t
Evdrv1 Vn GND Vout GND 1
V3 Vp GND DC 0 PWL(0 0 100n 0 100.1n CACE{vdd})
**** begin user architecture code


.control


    * Step function applied at time 100ns, save transient data
    tran 10n CACE{Tmax}
    set wr_singlescale
    wrdata CACE{simpath}/CACE{filename}_CACE{N}.data V(Vout) V(Vp)
.endc




.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1




** IHP models
.lib cornerMOSlv.lib CACE{corner}
.lib cornerMOShv.lib CACE{corner}
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ


**** end user architecture code
**.ends

* expanding   symbol:  sg13g2_cace_ip__ota5t.sym # of pins=6
** sym_path: examples/sg13g2_cace_ip__ota5t/xschem/sg13g2_cace_ip__ota5t.sym
** sch_path: examples/sg13g2_cace_ip__ota5t/xschem/sg13g2_cace_ip__ota5t.sch
.subckt sg13g2_cace_ip__ota5t Vp Vn Vout VDD VSS Ib
*.ipin Vp
*.ipin Vn
*.opin Vout
*.iopin VDD
*.iopin VSS
*.ipin Ib
XM10 node Ib VSS VSS sg13_lv_nmos w=2u l=1u ng=2 m=1 mm_ok=1
XM11 Vout net1 VDD VDD sg13_lv_pmos w=2u l=1u ng=2 m=1 mm_ok=1
XM1 Ib Ib VSS VSS sg13_lv_nmos w=2u l=1u ng=2 m=1 mm_ok=1
XM2 net1 net1 VDD VDD sg13_lv_pmos w=2u l=1u ng=2 m=1 mm_ok=1
XM3 Vout Vn node VSS sg13_lv_nmos w=20u l=0.5u ng=4 m=1 mm_ok=1
XM4 net1 Vp node VSS sg13_lv_nmos w=20u l=0.5u ng=4 m=1 mm_ok=1
.ends

.GLOBAL GND
.end
