** sch_path: examples/sg13g2_cace_ip__ota5t/cace/templates/ac.sch
**.subckt ac
I0 VDD Ib CACE{ib}
C1 Vout GND CACE{cl} m=1
V0 VSS GND 0
V2 VDD GND CACE{vdd}
E1 Vp net2 net1 GND 0.5
E2 Vn net2 net1 GND -0.5
Vdm net1 GND ac 1
Vcm net2 GND CACE{vcm}
x1 Vp Vn Vout VDD VSS Ib sg13g2_cace_ip__ota5t
**** begin user architecture code


.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1




.control


    * run ac simulation
    ac dec 20 1k 100e6

    * measure parameters
    let vout_mag = abs(v(Vout))
    let vout_phase_margin = phase(v(Vout)) * 180/pi + 180
    meas ac A0 find vout_mag at=1k
    meas ac UGF when vout_mag=1 fall=1
    meas ac PM find vout_phase_margin when vout_mag=1

    echo $&A0 $&ugf $&PM > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc




** IHP models
.lib cornerMOSlv.lib CACE{corner}
.lib cornerMOShv.lib CACE{corner}
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ


**** end user architecture code
**.ends

* expanding   symbol:  sg13g2_cace_ip__ota5t.sym # of pins=6
** sym_path: examples/sg13g2_cace_ip__ota5t/xschem/sg13g2_cace_ip__ota5t.sym
** sch_path: examples/sg13g2_cace_ip__ota5t/xschem/sg13g2_cace_ip__ota5t.sch
.subckt sg13g2_cace_ip__ota5t Vp Vn Vout VDD VSS Ib
*.ipin Vp
*.ipin Vn
*.opin Vout
*.iopin VDD
*.iopin VSS
*.ipin Ib
XM10 node Ib VSS VSS sg13_lv_nmos w=2u l=1u ng=2 m=1 mm_ok=1
XM11 Vout net1 VDD VDD sg13_lv_pmos w=2u l=1u ng=2 m=1 mm_ok=1
XM1 Ib Ib VSS VSS sg13_lv_nmos w=2u l=1u ng=2 m=1 mm_ok=1
XM2 net1 net1 VDD VDD sg13_lv_pmos w=2u l=1u ng=2 m=1 mm_ok=1
XM3 Vout Vn node VSS sg13_lv_nmos w=20u l=0.5u ng=4 m=1 mm_ok=1
XM4 net1 Vp node VSS sg13_lv_nmos w=20u l=0.5u ng=4 m=1 mm_ok=1
.ends

.GLOBAL GND
.end
